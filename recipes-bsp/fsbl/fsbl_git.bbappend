FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

SRC_URI += "file://te_patches.patch"

XSCTH_APP_zynqmp = "Zynq MP FSBL (TE modified)"


