FILESEXTRAPATHS_prepend := "${THISDIR}/files:"

TRENZ_LINUX_DTSI = "system-user.dtsi"

SRC_URI += "file://${TRENZ_LINUX_DTSI}"

