IMAGE_INSTALL_append = " \
                       i2c-tools \
                       libgpiod \
                       ethtool \
                       tcpdump \
                       iperf3\
                       "

